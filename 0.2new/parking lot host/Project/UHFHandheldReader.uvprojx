# Keil uVision project UHFHandheldReader.uvprojx, settings and files
target stm32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F205VGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: parkinglothost_release0603
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER
  c include: ..\Src\lib\STM32F2xx_StdPeriph_Driver\inc;..\Src\lib\CMSIS\Device\ST\STM32F2xx\Include;..\Src\_Common;..\Src\lib\CMSIS\CM3\CoreSupport;..\Src\lib\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\Src\usr;..\Src\lib\libltkcpp;..\Src\usr\comm_model;..\Src\usr\general_model;..\Src\usr\operation_model;..\Src\usr\hw_model;..\Src\usr\main_model;..\Src\lib\libsm2;..\Src\usr\certification_model;..\Src\usr\extendllrp;..\Src\usr\vm_model;..\Src\usr\rf_model;..\Src\usr\hw_model;..\Src\usr\GUI_Model;..\Src\usr\Text_Lib;..\Src\usr\Air_interface;..\Src\usr\Air_Board;..\Src\usr\CAN_Model;..\Src\usr\RX485;..\Src\usr\READ_MODE;..\Src\usr\Air_Model\Timer;..\Src\usr\Air_Model\checksum;..\Src\usr\Air_Model\PLL;..\Src\usr\Air_Model\RadioAir;..\Src\usr\Air_Model\Rf_Oper;..\Src\usr\Air_Model\cancellation;..\Src\usr\RTC;..\Src\usr\radar_model;..\Src\usr\banister
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Main_Model
    ../Src/usr/main_model/: GetDeviceCapabilities.cpp GetDeviceCapabilities.h main_application.cpp model_base.h main_application.h model_base.cpp param_manager.cpp param_manager.h
  group CMSIS
    ../Src/lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Src/lib/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group Startup
    ../Src/lib/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group Common
    ../Src/_Common/: systick.c printf_usart.c
  group StdPeriph_Driver
    ../Src/_Common/: config.c
    ../Src/lib/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group Libltkcpp
    ../Src/lib/libltkcpp/: ltkcpp_array.cpp ltkcpp_element.cpp LLRP_Capabilities.cpp LLRP_General.cpp LLRP_NET.cpp LLRP_Operation.cpp ltkcpp_encdec.cpp ltkcpp_error.cpp ltkcpp_framedecode.cpp ltkcpp_frameencode.cpp ltkcpp_frameextract.cpp ltkcpp_genout.cpp ltkcpp_hdrfd.cpp ltkcpp_typeregistry.cpp ltkcpp_xmltextencode.cpp
  group General_Model
    ../Src/usr/general_model/: HbFrame_Operation.cpp HEXConvert.cpp general.h class_retain.cpp general_functions.cpp ManufacturerFrame.cpp ManufacturerFrame.h
  group Comm_Model
    ../Src/usr/comm_model/: base_comm.cpp serial_comm.cpp uart_bsp_comm.c
  group Operation_Model
    ../Src/usr/operation_model/: operationspec_execute_base.h operationreport_manager.cpp operationreport_manager.h operationspec_manager.cpp operationspec_manager.h tag_accessspec.cpp tag_accessspec.h tag_selectspec.cpp tag_selectspec.h tag_selectaccessresult.cpp tag_selectaccessresult.h OpspecResult.cpp OpspecResult.h tag_spec.cpp tag_spec.h operationspec_execute_base.cpp operation_process.cpp operation_process.h rf_oper_base.cpp Rf_Oper_gb.cpp Rf_Oper_gb.h operationspec_execute_gb.cpp operationspec_execute_gb.h operationspec_execute_hb.cpp operationspec_execute_hb.h Rf_Oper_hb.cpp Rf_Oper_hb.h
  group HW_Model
    ../Src/usr/hw_model/: IOCtrl.cpp MCUToSecureComm.cpp SPI_Communication.cpp rtc.c spi.c i2c.c sim_spi.c gpio.c charge.c sim_spi1.c mcu_led.c buzzer_led.c power_led.c sm.c EN25Q256.c key_exit.c adc_dac.c time2.c
    ../Src/usr/: lowpower.c
    ../Src/usr/RTC/: pcf8563.c
  group Start_Model
    ../Src/usr/: main.c stm32f2xx_it.c
    ../Src/lib/CMSIS/: Retarget.c
  group LibSm2
    ../Src/lib/libsm2/: mraes.c mralloc.c mrarth0.c mrarth1.c mrarth2.c mrarth3.c mrbits.c mrbrick.c mrcore.c mrcrt.c mrcurve.c mrebrick.c mrec2m.c mrecn2.c mrfast.c mrgcd.c mrgcm.c mrgf2m.c mrio1.c mrio2.c mrjack.c mrlucas.c mrmonty.c mrpower.c mrprime.c mrrand.c mrscrt.c mrshs.c mrshs256.c mrshs512.c mrsmall.c mrsroot.c mrstrong.c mrxgcd.c mrzzn2.c mrzzn2b.c mrzzn3.c sm2.c sm3.c
  group Certification_Model
    ../Src/usr/certification_model/: Sm2Certification.cpp Sm2Certification.h miracl.h mirdef.h sm2.h sm3.h types.h
  group ExtendLLRP
    ../Src/usr/extendllrp/: ExtendHbFrame_Operation.cpp ExtendHbFrame_Operation.h ExtendLLRP.cpp ExtendLLRP.h ExtendLLRP_Message_ID.h
  group Vm_Model
    ../Src/usr/vm_model/: VersionManager.cpp VersionManager.h Update_SM_Firmware.cpp Update_Mcu_Firmware.cpp
  group Rf_Model
    ../Src/usr/rf_model/: rf_manager.cpp rf_manager.h
  group Air_interface
    ../Src/usr/Air_interface/: spi1.c testReadTag.c
  group Air_Board
    ../Src/usr/Air_Board/: sm2.h sm3.h
  group RX485
    ../Src/usr/RX485/: rx485_rev.c rx485_send.c rx485_uart.c communication.h communication.c
  group READ_MODE
    ../Src/usr/READ_MODE/: read_manage.cpp
  group Air_cancellation
    ../Src/usr/Air_Model/cancellation/: ADC.c cancell_spi.c cancellation.c DAC1080S.c
  group Air_checksum
    ../Src/usr/Air_Model/checksum/: utility.c
  group Air_PLL
    ../Src/usr/Air_Model/PLL/: LMX2541.c
  group Ar_RadioAir
    ../Src/usr/Air_Model/RadioAir/: air_interface.c EPC.c timer3.c
  group Air_Rf_Oper
    ../Src/usr/Air_Model/Rf_Oper/: rf_oper.c DAC.c
  group Air_Timer
    ../Src/usr/Air_Model/Timer/: timer.c
  group Radar_Model
    ../Src/usr/radar_model/: radar_model.c
  group BANISTER
    ../Src/usr/banister/: banister.c banister.h
