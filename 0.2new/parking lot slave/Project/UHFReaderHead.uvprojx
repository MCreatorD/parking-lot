# Keil uVision project UHFReaderHead.uvprojx, settings and files
target stm32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F205RGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: parkinglotslave_release
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F2XX, USE_STDPERIPH_DRIVER
  c include: ..\Src\lib\STM32F2xx_StdPeriph_Driver\inc;..\Src\lib\CMSIS\Device\ST\STM32F2xx\Include;..\Src\_Common;..\Src\lib\CMSIS\CM3\CoreSupport;..\Src\lib\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\Src\usr;..\Src\usr\PLL;..\Src\usr\Timer;..\Src\usr\cancellation;..\..\multipoint_reader_head;..\Src\usr\RadioAir;..\Src\usr\RX485;..\Src\usr\Rf_Oper;..\Src\usr\checksum;..\Src\usr\LED;..\Src\usr\flash;..\Src\usr\radar_model;..\Src\usr\update
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../Src/lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Src/lib/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
    ../Src/lib/CMSIS/: Retarget.c
  group Startup
    ../Src/lib/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group Common
    ../Src/_Common/: systick.c printf_usart.c
  group StdPeriph_Driver
    ../Src/lib/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group Start_Model
    ../Src/usr/: main.c stm32f2xx_it.c
    ../Src/usr/Timer/: time2.c
  group PLL_Model
    ../Src/usr/PLL/: LMX2541.c
  group Timer_Model
    ../Src/usr/Timer/: timer.c
  group Cancellation_Model
    ../Src/usr/cancellation/: ADC.c cancellation.c DAC1080S.c sim_spi.c
  group RadioAir_Model
    ../Src/usr/RadioAir/: EPC.c air_interface.c communication.c timer3.c
  group RX485_Model
    ../Src/usr/RX485/: rx485_send.c rx485_rev.c rx485_uart.c
  group Rf_Model
    ../Src/usr/Rf_Oper/: rf_oper.c DAC.c
  group Checksum_Model
    ../Src/usr/checksum/: utility.c
  group LED_Model
    ../Src/usr/LED/: READ_LED.c ws2812b.c read_led_manage.h
  group Flash_Model
    ../Src/usr/flash/: EN25Q256.c soft_spi.c spi3.c flashmanage.c
  group Radar_Model
    ../Src/usr/radar_model/: radar_model.c
  group Update
    ../Src/usr/update/: update.c
