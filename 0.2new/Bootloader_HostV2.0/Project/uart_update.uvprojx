# Keil uVision project uart_update.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F205VGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uart_update +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F2XX,USE_STDPERIPH_DRIVER
  c include: ..\ST_Lib\CMSIS\CM3\CoreSupport;..\ST_Lib\STM32F2xx_StdPeriph_Driver\inc;..\ST_Lib\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\User_Code\User;..\User_Code\Bsp_Drive;..\User_Code\Download;..\User_Code\IAP;..\User_Code\Flash_Download
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ../ST_Lib/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group CMSIS
    ../ST_Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../ST_Lib/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group StdPeriph_Driver
    ../ST_Lib/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group Bsp_Drive
    ../User_Code/Bsp_Drive/: bsp_uart_update.c common.c BspTime.c sys.c delay.c stmflash.c
  group Download
    ../User_Code/Download/: download.c ymodem.c
  group IAP
    ../User_Code/IAP/: iap.c
  group User
    ../User_Code/User/: main.c stm32f2xx_it.c
  group Flash_Download
    ../User_Code/Flash_Download/: EN25Q256.c spi.c flash_download.c
